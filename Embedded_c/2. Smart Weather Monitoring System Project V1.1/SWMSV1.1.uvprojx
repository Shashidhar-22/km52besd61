# Keil uVision project SWMSV1.1.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SWMSV1.1
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: MAIN.c WIFI.h UART6.h timechange.h systick.h LCD.h I2C.h ADC.h
    ../LIBRARY/ADC_LM35/Objects/: ADC_LM35.lib
    ../LIBRARY/KM I2C LIBRARY/: RaayanMini_KM_HAL_I2C_Libraries.lib
    ../LIBRARY/KM SYSTICK TIMER LIBRARY/Objects/: SYSTICK LIBRARY.lib
    ../LIBRARY/LCD1/Objects/: LCD.lib
    ../LIBRARY/TIMECHANGE/Objects/: time change.lib
    ../LIBRARY/UART6/Objects/: UART6.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
